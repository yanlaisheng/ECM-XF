# IAR project robotcontrol.ewp, settings and files
configuration robotcontrol (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\HARDWARE\Ethercat; ..\HARDWARE\W25QXX; ..\HARDWARE\WK2124; ..\MOTOR2; ..\HARDWARE\EtherCAT-XF
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\MOTOR3
  OBJCOPY.OOCOutputFile: robotcontrol.hex
  ILINK.IlinkOutputFile: robotcontrol.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/MOTOR2
    ../MOTOR2/: motor.c motor_it.c MotorStart.c
  group Application/User/Core
    ../Core/Src/: bsp_MOTOR1.c bsp_MOTOR2.c bsp_MOTOR3.c bsp_MOTOR4.c bsp_MOTOR5.c bsp_MOTOR6.c com1_232.c com2_232.c com3_232.c com4_232.c com5_232.c com6_232.c DoWith.c ds1302.c LinkTable.c MotorControl.c stmflash.c wk_port1.c wk_port2.c wk_port3.c wk_port4.c main.c gpio.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_crc.h
  group HARDWARE
    ../HARDWARE/Ethercat/: ecm_opcmd.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/WK2124/: wk2xxx.c
  group HARDWARE/EtherCAT-XF
    ../HARDWARE/EtherCAT-XF/: crc32.c EcmDriver.h EcmGpioDriver.c EcmUsrDriver.c EcmUsrDriver.h main_ini.c PdoDefine.h platform.c platform.h
